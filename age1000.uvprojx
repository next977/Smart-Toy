# Keil uVision project age1000.uvprojx, settings and files
target age1000 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: age1000
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin Obj\age1000.axf --output Binary\age1000.bin
  c flags: Optim=1 oTime=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,HSE_VALUE=12000000
  c include: .\Include;.\6050;.\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8003200 size 0x1ce00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./Source/: main.c MCUSettings.c stm32f10x_it.c melody.c button.c bluetooth.c motor.c flash.c gyro.c led.c blockgame.c sensor.c
  group Periph_Lib
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User_Lib
    ./Source/: miscellaneous.c mpu9150.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
